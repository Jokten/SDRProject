options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 48000*16
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jonte/Documents/gnurd/gr-logo.png
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(5,[0x01,0x02,0x03, 0x04, 0x05]))
    period: '100'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"frame_len"'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: pre amble
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_1
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '60'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.c_len = len (self.char_list)\n        # print (self.c_len)\n        self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.f_len = len (self.filler)\n\n    def work(self, input_items, output_items):\n\n        if (self.state == 0):\n            # idle\n            return (0)\n\n        elif (self.state == 1):\n            # send preamble\n            if (self._debug):\n                print (\"state = 1\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 64):\n                self.pre_count = 0\n                self.state = 2      # send msg\n            return (self.c_len)\n\n        elif (self.state == 2):\n            while (not (self._eof)):\n                buff = self.f_in.read (self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 3      # send file name\n                    self.pre_count = 0\n                    break\n                # convert to Base64\n                encoded = base64.b64encode (buff)\n                e_len = len(encoded)\n                if (self._debug):\n                    print ('b64 length =', e_len)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key0,   # Key of the tag\n                    val0    # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                return (e_len)\n\n        elif (self.state == 3):\n            # send file name\n            fn_len = len (self.FileName)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(fn_len+8)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += (fn_len+8)\n            i = 0\n            while (i < 8):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            j = 0\n            while (i < (fn_len+8)):\n                output_items[0][i] = ord(self.FileName[j])\n                i += 1\n                j += 1\n            self.state = 4\n            return (fn_len+8)\n\n        elif (self.state == 4):\n            # send post filler\n            if (self._debug):\n                print (\"state = 4\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.f_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.f_len\n            i = 0\n            while (i < self.f_len):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 16):\n                self.pre_count = 0\n                self.state = 0      # idle\n            return (self.f_len)\n\n        return (0)\n\n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass add_preamble(gr.basic_block):\n    \"\"\"\n    A custom GNU Radio block that prepends a fixed preamble to the input byte data.\n    \"\"\"\n    def __init__(self, preamble=[0xAA, 0x55, 0xAA, 0x55]):\n        gr.basic_block.__init__(self,\n            name=\"add_preamble\",\n            in_sig=[np.uint8],   # Input signal is bytes (unsigned 8-bit integers)\n            out_sig=[np.uint8])  # Output signal is also bytes\n\n        # Store the preamble as a numpy array of type uint8\n        self.preamble = np.array(preamble, dtype=np.uint8)\n        # Initialize an index to keep track of preamble transmission\n        self.preamble_index = 0\n        # Flag to indicate if the preamble has been sent\n        self.preamble_sent = True\n        self.tag_transmitted = False\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n        ninput_items = len(in0)\n        noutput_items = len(out)\n        #print(ninput_items)\n        #print(noutput_items)\n        #print(\"working\")\n\n        out_idx = 0  # Output buffer index\n\n        # Process tags in the input items being consumed\n        tags = self.get_tags_in_window(0, 0, ninput_items)\n        for tag in tags:\n            if pmt.equal(tag.key, pmt.intern(\"start_packet\")) and self.preamble_sent and self.tag_transmitted:\n                # Determine the position of the tag in the input buffer\n                tag_idx = tag.offset - self.nitems_read(0)\n                print(f\"Found tag at offset {tag.offset}, tag_idx {tag_idx}\")\n                if 0 <= tag_idx < ninput_items:\n                    # Reset preamble state when a new packet starts\n                    #print(\"found packet start\")\n                    self.preamble_sent = False\n                    self.preamble_index = 0\n                    # Consume up to the tag position to avoid reprocessing\n                    self.consume(0, tag_idx)\n                    # Adjust input items after consuming up to tag_idx\n                    in0 = in0[tag_idx:]\n                    ninput_items = len(in0)\n                    break  # Assuming one tag per general_work call\n\n        # Now, decide whether to send the preamble\n        if not self.preamble_sent:\n            preamble_remaining = len(self.preamble) - self.preamble_index\n            output_space = noutput_items\n\n            # Determine how many bytes to copy\n            n_to_copy = min(preamble_remaining, output_space, ninput_items)\n            out[:n_to_copy] = self.preamble[self.preamble_index:self.preamble_index + n_to_copy]\n            self.preamble_index += n_to_copy\n            out_idx += n_to_copy\n\n            # print(out)\n\n            # Check if the preamble has been fully sent\n            if self.preamble_index == len(self.preamble):\n                print(\"Preambled\")\n                self.preamble_sent = True\n                self.tag_transmitted = False\n\n            self.produce(0, out_idx)\n            return gr.WORK_CALLED_PRODUCE  # Return the correct flag\n\n        # After the preamble has been sent, forward the input data\n        n_to_copy = min(ninput_items, noutput_items - out_idx)\n        out[out_idx:out_idx + n_to_copy] = in0[:n_to_copy]\n        out_idx += n_to_copy\n\n        # Consume input items and produce output items\n        self.consume(0, n_to_copy)\n        self.produce(0, out_idx)\n        #print(in0)\n        #print(out)\n        self.tag_transmitted = True\n        return gr.WORK_CALLED_PRODUCE  # Return the correct flag\n\n"
    preamble: '[0xAA, 0x55, 0xAA, 0x55, 0xAA, 0x55, 0xAA, 0x55]'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass add_packet_start_tag(gr.sync_block):\n    \"\"\"\n    A custom GNU Radio sync block that adds a \"packet_start\" tag\n    at the start of each packet, using the \"packet_len\" tag to determine packet length.\n    \"\"\"\n    def __init__(self, packet_len_tag_key=\"packet_len\"):\n        gr.sync_block.__init__(self,\n            name=\"add_packet_start_tag\",\n            in_sig=[np.uint8],    # Input signal (bytes)\n            out_sig=[np.uint8])   # Output signal (bytes)\n\n        # Store the tag key for packet length\n        self.packet_len_tag_key = pmt.intern(packet_len_tag_key)\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        # Copy input data to output buffer\n        noutput_items = len(out)\n        out[:] = in0[:noutput_items]\n\n        # Retrieve tags that represent packet boundaries (with packet lengths)\n        tags = self.get_tags_in_window(0, 0, noutput_items)\n        \n        for tag in tags:\n            # Check if the tag is the packet length tag\n            if pmt.equal(tag.key, self.packet_len_tag_key):\n                # Convert the tag value from PMT to a Python integer\n                packet_len = pmt.to_long(tag.value)\n                #print(\"found tag\")\n                #print(packet_len)\n                if packet_len > 0:\n                    # Get the start of the packet (where the tag is located)\n                    packet_start = tag.offset - self.nitems_written(0)\n                    #print(\"Added tag\")\n                    # Ensure the packet start is within the current output buffer\n                    if 0 <= packet_start < noutput_items:\n                        # Add a \"packet_start\" tag at the beginning of the packet\n                        self.add_item_tag(0,                # Output port index\n                                          self.nitems_written(0) + packet_start,  # Tag position in the stream\n                                          pmt.intern(\"start_packet\"),             # Tag key\n                                          pmt.PMT_NIL)                            # Tag value (optional)\n\n        return noutput_items\n\n"
    packet_len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: usrp_rate/sps
    center_freq0: 2.45*10**9
    gain0: '20'
    samp_rate: usrp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', virtual_sink_0_0, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, digital_crc_append_0, in]
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_2, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', fft_filter_xxx_0_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [epy_block_1, '0', virtual_sink_0_0, '0']
- [epy_block_2, '0', blocks_tag_debug_0_1, '0']
- [epy_block_2, '0', epy_block_1, '0']
- [fft_filter_xxx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', blocks_tag_debug_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, digital_crc_append_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
